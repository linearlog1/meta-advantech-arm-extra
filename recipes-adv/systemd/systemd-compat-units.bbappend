
SYSTEMD_DISABLED_SYSV_SERVICES = " \
	busybox-udhcpc \
	hwclock \
	nfsserver \
	nfscommon \
	syslog.busybox \
"

